# Keil uVision project Template.uvprojx, settings and files
target Project (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: Template +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 wLevel=4
  c include: .\hc32f072\mcu\common;.\hc32f072\driver\inc;.\hc32f072\midware\inc;.\userapp\inc;.\userapp\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep=*Handler
  group hc32f072/common
    ./hc32f072/mcu/common/: system_hc32f072.c interrupts_hc32f072.c
    ./hc32f072/: startup_hc32f072.s
  group hc32f072/driver
    ./hc32f072/driver/src/: ddl.c sysctrl.c
  group userapp/source
    ./userapp/src/: main.c
  group userapp/include
    ./userapp/inc/: ddl_device.h
software components: CMSIS:CORE 5.6.0
