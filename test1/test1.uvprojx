# Keil uVision project test1.uvprojx, settings and files
target Project (6190000::V6.19::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: test1 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 wLevel=4
  c include: .\hc32f072\mcu\common;.\hc32f072\midware\inc;.\userapp\src;.\userapp\inc;.\Ethernet;.\hc32f072\driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep=*Handler
  group hc32f072/common
    ./hc32f072/mcu/common/: system_hc32f072.c interrupts_hc32f072.c
    ./hc32f072/: startup_hc32f072.s
  group hc32f072/driver
    ./hc32f072/driver/src/: ddl.c sysctrl.c can.c gpio.c spi.c reset.c wizchip_conf.c socket.c w5500.c uart.c
  group userapp/source
    ./userapp/src/: main.c
  group userapp/include
    ./userapp/inc/: ddl_device.h
software components: CMSIS:CORE 5.6.0
